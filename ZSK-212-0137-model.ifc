Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-09-22T14:18:48+00:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcProject, ОРИОН ZSK-212-0137
Classification: Классификатор строительных ресурсов (КСР)

# IfcFurnishingElement: Оборудование благоустройства, ZSK-212-0137 Тематический игровой комплекс (Транспорт) «Космическая ракета»
In: Площадка
Description: Оборудование благоустройства. Тематический игровой комплекс (Транспорт) «Космическая ракета»; Classification: 59.1.15.01-0532 Комплекс игровой (Классификатор строительных ресурсов (КСР))
Pset_ManufacturerTypeInformation - Manufacturer: Завод современных конструкций (ЗСК) · ООО «ПКФ «ОРИОН» · зск.рф · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: ZSK-212-0137; ModelReference: Тематический игровой комплекс (Транспорт) «Космическая ракета»; ProductionYear: 2026; ArticleNumber: ZSK-212-0137
ORION_Изделие - Артикул: ZSK-212-0137; Артикул прежний: SD-212-0137; Наименование: Тематический игровой комплекс (Транспорт) «Космическая ракета»; Изготовитель: ООО «ПКФ «ОРИОН»; Марка: Завод современных конструкций (ЗСК); Город: Миасс, Челябинская область; Габариты: 7.3 x 5.2 м; Зона безопасности: 11.0 x 8.8 м; Высота свободного падения: 1.5 м; Возраст: для детей от 2 до 12 лет; Цена: 5 499 920 ₽; Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; Карточка изделия: https://зск.рф/catalog/transport/3011; Код КСИ: CPr>EDB080; Класс КСИ: Комплекс игровой; Коды КСР: 59.1.15.01-0532 … 59.1.15.01-0595
ADSK - ADSK_Наименование: Тематический игровой комплекс (Транспорт) «Космическая ракета»; ADSK_Марка: ZSK-212-0137; ADSK_Код изделия: 59.1.15.01-0532; ADSK_Завод-изготовитель: ООО «ПКФ «ОРИОН»; ADSK_Единица измерения: шт.; ADSK_Количество: 1; ADSK_Обозначение: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ADSK_URL страницы изделия: https://зск.рф/catalog/transport/3011
ZSK_Благоустройство - ZSK_Возрастная_группа: для детей от 2 до 12 лет; ZSK_Зона_безопасности: 11.0 x 8.8 м; ZSK_Высота_свободного_падения: 1.5 м; ZSK_Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ZSK_Код_КСИ: CPr>EDB080; ZSK_Артикул_прежний: SD-212-0137
Qto_ORION - Длина: 7300 mm; Ширина: 5200 mm; Высота: 0 mm
